# Repository elatorre20/RICM_pico

File README.md:

*** RICMPIco ***

The software for a raspberry PIco-based kit
board for a tic-tac-toe game. The board is 
mostly based on I2C devices, and will be 
simple to assemble so that we can use it
in children's workshops. Written in 
micropython and C.

Developed at Rhode Island Computer Museum

Dan Berman, Emilio Latorre, Mike Thompson - 2021

Changelog:
	
	# 0.0.1:
		+ added example micropython sketches for the 
		1306 OLED display. Simple patterns demonstrating 
		text and pixel graphics.

## KiCad design CAD/RICM_pico/RICM_pico.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11: 0.1 μf; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9: WS2812B; LED_D8.0mm_RGB
DS1, DS2: OLED_module_128x64; OLED__module_128x64
J1: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Vertical
J2: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
LS1: Speaker; Buzzer_12x9.5RM6.5
R3, R4, R5, R6, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R11, R12, R13, R15, R16, R17: 75; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R14: 57; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN1, RN2, RN3: 10k; R_Array_SIP10
RV1, RV2: 100k; Potentiometer_Tayda_Linear_20mm
RV3: R_POT; Potentiometer_17mm_vertical
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18: SW_Push; SW_PUSH_6mm_2pin
SW19: SW_DIP_x07; DIP-14_W7.62mm
U1: Pico; RPi_Pico_SMD_TH
U2, U3: PCA9555D; SOIC-24W_7.5x15.4mm_P1.27mm

Connections:
+3V3: C1.1, C2.1, DS1.2 (VCC), DS2.2 (VCC), J1.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, RV1.3, RV2.3, RV3.3, U1.36 (3V3), U2.24 (VDD), U3.24 (VDD)
+5V: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, D1.2 (VDD), D2.2 (VDD), D3.2 (VDD), D4.2 (VDD), D5.2 (VDD), D6.2 (VDD), D7.2 (VDD), D8.2 (VDD), D9.2 (VDD), J2.2, RN1.1 (common), RN2.1 (common), RN3.1 (common), U1.40 (VBUS)
AGND: RV1.1, RV2.1, RV3.1, U1.33 (AGND)
DO0: R9.1, U1.21 (GPIO16)
Earth: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), DS1.1 (GND), DS2.1 (GND), J1.1, J2.1, LS1.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW19.8, SW19.9, SW19.10, SW19.11, SW19.12, SW19.13, SW19.14, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.38 (GND), U2.2 (A1), U2.3 (A2), U2.12 (VSS), U2.21 (A0), U3.2 (A1), U3.3 (A2), U3.12 (VSS), U3.21 (A0)
GPIO10: J1.6, U1.14 (GPIO10)
GPIO11: J1.5, U1.15 (GPIO11)
GPIO12: J1.4, U1.16 (GPIO12)
GPIO13: J1.3, U1.17 (GPIO13)
INT0: R7.1, U1.11 (GPIO8), U2.1 (~INT)
INT1: R8.1, U1.12 (GPIO9), U3.1 (~INT)
unnamed: D1.1 (DOUT), R10.2
unnamed: D1.4 (DIN), R9.2
unnamed: D2.1 (DOUT), R11.2
unnamed: D2.4 (DIN), R10.1
unnamed: D3.1 (DOUT), R12.1
unnamed: D3.4 (DIN), R11.1
unnamed: D4.1 (DOUT), R15.1
unnamed: D4.4 (DIN), R14.1
unnamed: D5.1 (DOUT), R14.2
unnamed: D5.4 (DIN), R13.1
unnamed: D6.1 (DOUT), R13.2
unnamed: D6.4 (DIN), R12.2
unnamed: D7.1 (DOUT), R16.2
unnamed: D7.4 (DIN), R15.2
unnamed: D8.1 (DOUT), R17.2
unnamed: D8.4 (DIN), R16.1
unnamed: D9.4 (DIN), R17.1
unnamed: LS1.1, U1.10 (GPIO7)
unnamed: RV1.2, U1.34 (GPIO28_ADC2)
unnamed: RV2.2, U1.32 (GPIO27_ADC1)
unnamed: RV3.2, U1.31 (GPIO26_ADC0)
SCL0: DS1.3 (SCL), J1.9, R3.1, U1.27 (GPIO21), U2.22 (SCL)
SCL1: DS2.3 (SCL), J1.7, R5.1, U1.25 (GPIO19), U3.22 (SCL)
SDA0: DS1.4 (SDA), J1.10, R4.1, U1.26 (GPIO20), U2.23 (SDA)
SDA1: DS2.4 (SDA), J1.8, R6.1, U1.24 (GPIO18), U3.23 (SDA)
c1: U3.14 (IO1_1)
c2: U3.15 (IO1_2)
c3: U3.16 (IO1_3)
c4: U3.17 (IO1_4)
c5: U3.18 (IO1_5)
c6: U3.19 (IO1_6)
c7: U3.20 (IO1_7)
sw1: RN1.2 (R1), SW1.1, U2.13 (IO1_0)
sw2: RN1.3 (R2), SW2.1, U2.11 (IO0_7)
sw3: RN1.4 (R3), SW3.1, U2.10 (IO0_6)
sw4: RN1.5 (R4), SW4.1, U2.9 (IO0_5)
sw5: RN1.6 (R5), SW5.1, U2.8 (IO0_4)
sw6: RN1.7 (R6), SW6.1, U2.7 (IO0_3)
sw7: RN1.8 (R7), SW7.1, U2.6 (IO0_2)
sw8: RN1.9 (R8), SW8.1, U2.5 (IO0_1)
sw9: RN1.10 (R9), SW9.1, U2.4 (IO0_0)
sw10: RN2.3 (R2), SW10.1, U3.4 (IO0_0)
sw11: RN2.4 (R3), SW11.1, U3.5 (IO0_1)
sw12: RN2.5 (R4), SW12.1, U3.6 (IO0_2)
sw13: RN2.6 (R5), SW13.1, U3.7 (IO0_3)
sw14: RN2.7 (R6), SW14.1, U3.8 (IO0_4)
sw15: RN2.8 (R7), SW15.1, U3.9 (IO0_5)
sw16: RN2.9 (R8), SW16.1, U3.10 (IO0_6)
sw17: RN2.10 (R9), SW17.1, U3.11 (IO0_7)
sw18: RN2.2 (R1), SW18.1, U3.13 (IO1_0)
sw19: RN3.8 (R7), SW19.1, U2.14 (IO1_1)
sw20: RN3.7 (R6), SW19.2, U2.15 (IO1_2)
sw21: RN3.6 (R5), SW19.3, U2.16 (IO1_3)
sw22: RN3.5 (R4), SW19.4, U2.17 (IO1_4)
sw23: RN3.4 (R3), SW19.5, U2.18 (IO1_5)
sw24: RN3.3 (R2), SW19.6, U2.19 (IO1_6)
sw25: RN3.2 (R1), SW19.7, U2.20 (IO1_7)

Board: 2 copper layers, 203.0 x 88.0 mm, 68 parts (0 on the bottom side), 61 nets.

## Commit log

2021-05-09 OLED example sketches
2021-05-10 screen code and datasheets
    added more demo routines with the OLED display. Also added a folder for datasheets of chips used in the project.
2021-05-11 started on 7-segment
2021-05-14 Update OLED_tictac.py
    Added basic functions for drawing the tic tac toe board and placing marks on it
2021-05-15 Update OLED_tictac.py
    updated the tic tac toe board to track the state of the board and check for wins
2021-05-15 Update OLED_tictac.py
    added a splash message and cleaned up some things
2021-05-15 Image
    made a sketch to display 1-BPP bitmap images
2021-05-16 edited image
    added a function to streamline image importation and conversion. Now you can save any monochrome (1-bpp) bitmap to the pico and display it on the oled screen
2021-05-17 clock
    working on displaying graphics. added image digits and some code to display multiple images at once.
2021-05-17 worked on clock
    added a stopwatch function to clock.py
2021-05-18 updated for the new oleds
2021-05-18 Create LED_test.py
    added a script to use RBG LEDs through GPIO. eventually we will switch to using an I2C LED controller, this is just for testing
2021-05-18 OLED and tictactoe updates
    Moved the OLED driver code into a library. Instructions on how to upload the libraries to the pico are in the /libraries folder. Also updated the tictactoe code to be resizable for the new screens
2021-05-23 Added library for the LED controller
    Added library code to use the PCA9532 I2C LED controller
2021-05-24 Update LEDS.py
    added a queryable state for the LEDs
2021-05-24 Update LEDS.py
    added code to update one LED at a time by reading state and replacing only the affected LED
2021-05-24 working on LED code
    Having some problems with the LED driver losing bytes. trying to figure out how to use delays to fix it
2021-05-27 troubleshooting I2C issues with the LED chip
2021-05-30 added RBG LEDs
    Fixed up the protoboard to resolve some issues with unreliable connections. added some code related to using RBG LEDs with the PCA9532 chip.
2021-05-31 Update LEDS.py
    Added in some more code to make the state of individual LEDs queryable independent of whole registers
2021-06-02 worked on OLED
    Added code to OLED_image to display animations, using bitmap frames
2021-06-06 created library for piezo buzzer
    added some code to play music using PWM on a piezo buzzer
2021-06-15 fixed I2C read methods
    Fixed a bug in the functions for reading data from i2c registers on devices that was causing reads from the incorrect address
2021-07-06 Added board cad files
    Added KiCad files for the PCB. Custom symbols used should be included. At this stage, the schematic is finished except for the OLED modules, and the layout is approximately 25% done. Routing is not s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
2021-07-06 Cad files update
    Finished laying out the PCB and ran the traces through the autorouter. Routing looks ok but may need some cleanup.
2021-07-08 updates on cad files
    Cleaned up the symbol diagram to make it more readable. Finished the layout with custom symbols for the pushbutton and screen modules. Started work on the routing, approximately 50% done. Hoping to o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
2021-07-09 updated cad files again
    Finished the routing for the prototype board. Theoretically ready to order the first run of 5.
2021-07-09 replotted gerbers
2021-07-09 replotted gerbers
    changed the size of capacitor C1 and replotted gerbers to reflect
2021-07-09 updated cad files
    Fixed some errors including hooking the chip VCCs and pullups to 3v3 instead of 5v. Replotted gerbers to reflect
2021-07-10 updated cad files
    Switched to USB only power. Switched RV3 to a full-size pot with knob. Fused auxiliary connector power. Added small capacitors across each chip. Final revision before prototype order.
2021-07-12 fixed gerbers
    Fixed gerbers to comply JLCPCB naming conventions.
2021-07-15 Wrote assembly diagnostics
    Added some simple diagnostic routines for specific parts, to be run during assembly.
2021-07-20 update to cad files and diagnostics
    Updated the symbol diagram with address labels for the I2C devices. Mike cleaned up the I2C diagnostic.
2021-07-22 Fixed cad and updated diagnostics
    Fixed CAD drawings to reflect some issues with the prototype PCBS (missing labels, OLED GND/VCC reversed). Updated diagnostics to include one to test both LED chip at once, cycling through all LEDs.
2021-07-22 Diagnostics and CAD updates
    Updated GPIO diagnostic to allow testing individual switches. Updated CAD files to reflect proper drill sizes on F1 and RV3. Fixed spacing and reference placement on R4, R8, R3, and R7.
2021-07-24 Cad revisions
    Updated footprints for RV1 and RV2 to match new parts from tayda. Updated footprints of LEDS for proper pin spacing. Fixed spacing on footprint of LS1.
2021-07-25 Fixed errors in cad files
    Fixed pinout errors on RV1 and RV2. Eliminated the PCA9532 chips in favor of using individually controlled WS2811D LED packages. Added supporting resistors and capacitors for aforementioned LEDS.
2021-08-03 small fixes on CAD files
    Fixed board edges and corner support holes.
2021-08-13 further improvements to CAD
    Labeled +5v auxiliary connector. fixed drill sizes for pushbutton.
2021-08-13 replotted gerbers for v0.2 final revision
2021-08-28 CAD and diagnostics updates
    Updates to CAD files to reflect errors found in rev2 prototype. Swapped references for r4 and r8. Swapped reversed pins on rv1 and rv2. Expanded the external connector to include hookups for i2c0 and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
    Merged in updated diagnostics by Mike Thompson.
2021-08-29 Added speaker tests.
2021-08-29 Added some datasheets.
2021-08-29 Updated the 12-Switches-LEDs.py diagnostic
2021-08-31 Updated diagnostics
2021-08-31 More Diagnostic updates.
2021-09-01 Added initial trial of PONG measurements and movement
2021-09-01 Updated PONG
2021-09-02 Changed OLED message
2021-09-02 Monir improvements
2021-09-02 Minor improvements
2021-09-11 Player #2, the end near the potentiometer, is working
2021-09-16 Two Player PONG is working better.
2021-10-02 overclocked I2C bus to make pong smoother
    overclocked the I2C bus up to 1.5mhz from 400khz, makes the game run much smoother. still have to figure out the issue with the offset on the paddle coordinates on screen 1
2021-10-16 Fixed pong misalignment issue
    Pong now has the correct paddle position on both screens
